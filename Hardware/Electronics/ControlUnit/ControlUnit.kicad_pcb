# Repository GJN-Aerospace/Halcyon

## KiCad design Hardware/Electronics/ControlUnit/ControlUnit.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1, C4, C6, C8, C11, C12, C13, C14, C16, C19: 100nF; C_0805_2012Metric
C2, C3: 12pF; C_0805_2012Metric
C5: 220nF; C_0805_2012Metric
C7, C9: 1uF; C_0805_2012Metric
C10: 10uF; C_0805_2012Metric
C15, C17, C18, C20: 100uF; CP_Elec_6.3x7.7
C21: 10nF; C_0805_2012Metric
C22: 100n; C_0805_2012Metric
D1: D_Zener; D_DO-41_SOD81_P10.16mm_Horizontal
D2: LED_RCGB; LED_D5.0mm-4_RGB
D3, D4, D5, D6: LED; LED_1206_3216Metric
D7, D8: D_Schottky; DIOM5436X244N
F1: 500mA; Fuse_1206_3216Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965_Pad
J1: Screw_Terminal_01x02, Batt 9V; TerminalBlock_4Ucon_1x02_P3.50mm_Horizontal
J2: USB_B_Mini; USB_Mini-B_Tensility_54-00023_Vertical_CircularHoles
J3: Conn_01x05; ProgPins_01x05_2.54mm
J4, J5: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical
J6: Micro_SD_Card; microSD_HC_Molex_502774-0891
J7: S1; PinHeader_1x03_P2.54mm_Vertical
J8: BME280
J9: S2; PinHeader_1x03_P2.54mm_Vertical
J10: S3; PinHeader_1x03_P2.54mm_Vertical
J11: MPU-6050/MPU-9250; MPU-9250-4pin
J12: S4; PinHeader_1x03_P2.54mm_Vertical
J13: Conn_01x02; SMD_PinHeader_01x02_2.54mm
JP1: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
L1: 10uH; L_0805_2012Metric
Q1, Q2: SOT-23
R1, R2, R3, R14, R16: 10k; R_0805_2012Metric
R4, R5, R6: 220; R_0805_2012Metric
R7, R8, R9: 100k; R_0805_2012Metric
R10, R11, R12, R13: R; R_0805_2012Metric
R15: 470; R_0805_2012Metric
SW1: SW_DPDT_x2; Sw1
SW2: SW_Push; Push_Switch_TS1107GS-5
U1: ATSAMD21G18A-AFT; TQFP-48_7x7mm_P0.5mm
U2: LM340_SOT223/LM7805_5V; SOT-223-3_TabPin2
U3: MCP1826S_3.3V; SOT-223-3_TabPin2
U4: RFM69W; HOPERF_RFM69HW
U5: MAX-8Q; ublox_MAX
U6: W25Q32JVSS; SOIC-8_5.23x5.23mm_P1.27mm
Y1: 32.768kHz; Crystal_C26-LF_D2.1mm_L6.5mm_Horizontal

Connections:
+3V3: C1.1, C4.1, C11.1, C12.1, C13.1, C14.1, C16.1, C19.1, F1.1, J3.1, J6.4 (VDD), J8.1, J11.1, L1.1, R1.1, R2.1, R3.1, R11.1, R12.1, R13.1, R15.1, U1.17 (VDDIO), U1.36 (VDDIO), U1.44 (VDDIN), U4.8 (3.3V), U5.6 (V_BCKP), U5.7 (VCC_IO), U5.8 (VCC), U6.8 (VCC)
/BZ: BZ1.1 (-), U1.8 (PB09)
/B_LED: R6.1, U1.9 (PA04)
/Batt: C22.1, R8.1, R9.1, U1.7 (PB08)
/CS_FLASH: U1.29 (PA20), U6.1 (~CS)
/CS_RAD: U1.22 (PA13), U4.15 (NSS)
/CS_SD: J6.2 (DAT3/CD), U1.37 (PB22)
/D13: R10.1, U1.26 (PA17)
/DIO0: U1.12 (PA07), U4.2 (DIO0)
/G_LED: R5.1, U1.10 (PA05)
/MISO: J6.7 (DAT0), U1.21 (PA12), U4.13 (MISO), U6.2 (DO(IO1))
/MOSI: J6.3 (CMD), U1.19 (PB10), U4.14 (MOSI), U6.5 (DI(IO0))
/RESET: C21.1, J3.2, R3.2, SW2.1, U1.40 (~RESET)
/RX_GPS: U1.27 (PA18), U5.3 (RXD)
/RX_LED: D5.1 (K), U1.48 (PB03)
/R_LED: R4.1, U1.11 (PA06)
/SCK: J6.5 (CLK), U1.20 (PB11), U4.12 (SCK), U6.6 (CLK)
/SCL: J8.3, J11.3, R2.2, U1.32 (PA23), U5.17 (SCL)
/SDA: J8.4, J11.4, R1.2, U1.31 (PA22), U5.16 (SDA)
/SWCLK: J3.3, U1.45 (PA30)
/SWDIO: J3.4, U1.46 (PA31)
/Servo_1: J7.1, U1.13 (PA08)
/Servo_2: J9.1, U1.14 (PA09)
/Servo_3: J10.1, U1.23 (PA14)
/Servo_4: J12.1, U1.24 (PA15)
/TX_GPS: U1.25 (PA16), U5.2 (TXD)
/TX_LED: D4.1 (K), U1.39 (PA27)
/USB_D+: J2.3 (D+), U1.34 (PA25)
/USB_D-: J2.2 (D-), U1.33 (PA24)
/Vbatt: C5.1, R8.2, SW1.1 (A), U2.1 (VI)
GND: BZ1.2 (+), C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.1, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, D2.2 (K), D3.1 (K), J1.1, J2.5 (GND), J2.6 (Shield), J3.5, J4.2 (Ext), J5.2 (Ext), J6.6 (VSS), J6.9 (SHIELD), J7.3, J8.2, J9.3, J10.3, J11.2, J12.3, JP1.2 (B), R7.1, R9.2, R14.2, R16.2, U1.5 (GNDANA), U1.18 (GND), U1.35 (GND), U1.42 (GND), U2.2 (GND), U3.2 (GND), U4.9 (GND), U4.11 (GND), U5.1 (GND), U5.10 (GND), U5.12 (GND), U6.4 (GND)
unnamed: C2.2, U1.1 (PA00), Y1.1
unnamed: C3.1, U1.2 (PA01), Y1.2
unnamed: C7.2, U1.43 (VDDCORE)
unnamed: C8.1, L1.2, U1.6 (VDDANA)
unnamed: C10.1, F1.2, U3.3 (VO)
unnamed: D1.2, J1.2
unnamed: D1.1, SW1.2 (B)
unnamed: D2.1 (RA), R4.2
unnamed: D2.3 (GA), R5.2
unnamed: D2.4 (BA), R6.2
unnamed: D3.2 (A), R10.2
unnamed: D4.2 (A), R11.2
unnamed: D5.2 (A), R12.2
unnamed: D6.1 (K), JP1.1 (A)
unnamed: D6.2 (A), R13.2
unnamed: J4.1 (In), U4.10 (ANA)
unnamed: J5.1 (In), U5.11 (RF_IN)
unnamed: J13.1, U1.16 (PA11)
unnamed: J13.2, U1.15 (PA10)
unnamed: R7.2, SW2.2
unnamed: R15.2, U6.7 (IO3)

Notes on the sheet:
XDA XCL ADO INT
EDA ECL ADO INT NCS FSYNC
Microcontroller
Optional devices
Transceiver
GNSS module
Servos
Storage devices
microSD card slot
Flash chip
Sensors
Power management
Programming and reset
Mounting holes
State indicators

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
Board: 2 copper layers, 50.0 x 70.0 mm, 75 parts (29 on the bottom side), 56 nets.

Other parts of the board:
D9: D_Schottky; DIOM5436X244N

## Commit log

2021-03-09 Zkouška
    Test
2021-03-09 Addition of kicad files
2021-03-09 New "parts"
2021-03-12 initial work on electronics
2021-03-16 Changes
    New electronics design added.
2021-03-18 Changements...encore
2021-03-25 Encore
2021-03-27 Create Simulace v Pythonu
    Numerické simulace týkající se letu- řešení pohybových rovnic, aerodynamika, PID regulátor...
2021-04-14 PCB changes
2021-04-25 PDFs and gerber v1
